# Keil uVision project Ble_Vendor_Service.uvprojx, settings and files
target Ble_Vendor_Service (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: Ble_Vendor_Service +hex
  c flags: Optim=1
  c define: PIXART_ARM_PROJECT
  c include: .\Include;.\ble;.\Main
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x8000
  memory RVCT9: RAM 0x20001000 size 0x2000
  group Main
    ./Main/: main.c key.c led.c
  group Driver
    ./Driver/: ota.c syd8801_debug.c syd8801_delay.c syd8801_gpio.c syd8801_timer.c syd8801_uart.c syd8801_ioi2c.c syd8801_adc.c
  group BLE
    ./ble/: syd_8801_lib.lib
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.1
